## test/interactive/isr/main/Kconfig.projbuild
```kconfig
menu "ESP32 Button: ISR interactive test"

config INTERACTIVE_BUTTON_GPIO
    int "Which GPIO the button is on"
    default 0

endmenu
```
